Rod End (Autodesk Fusion 360 design; units mm, degrees)
description: STEP AP203
part number: 6498K908_Rod End for 16mm Bore Size Double-Acting Round Body Air Cylinder
base_feature "Base Feature"