Air Cylinder (Autodesk Fusion 360 design; units mm, degrees)
description: STEP AP203
part number: 6498K798_Round Body Air Cylinder
base_feature "Base Feature" bodies "Main Body", "Front Nut", "Rod", "Rear Nut"
combine "Combine1"
remove_body "RemoveBody5"
named bodies: "Main Body", "Front Nut", "Rod", "Rear Nut"