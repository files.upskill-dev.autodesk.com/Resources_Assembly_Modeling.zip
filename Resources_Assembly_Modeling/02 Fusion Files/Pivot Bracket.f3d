Pivot Bracket (Autodesk Fusion 360 design; units mm, degrees)
description: STEP AP203
part number: arrangementsContainer
base_feature "Base Feature" bodies "Clip1", "Pin", "Clip2", "Bracket"
named bodies: "Clip1", "Pin", "Clip2", "Bracket"